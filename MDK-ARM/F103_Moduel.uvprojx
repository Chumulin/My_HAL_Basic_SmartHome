# Keil uVision project F103_Moduel.uvprojx, settings and files
target F103_Moduel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103_Moduel +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ModuleDrivers;..\SmartDevice\CAL;..\SmartDevice\KAL;..\SmartDevice\Input_System;..\SmartDevice\Unit_Test;..\SmartDevice\Device;..\SmartDevice\Device\diaplay;..\SmartDevice\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ModuleDrivers
    ../ModuleDrivers/: driver_usart.c ring_buffer.c driver_key.c driver_led.c driver_i2c.c driver_oled.c ascii_font.c
  group kal
    ../SmartDevice/KAL/: kal_gpio_key.c kal_time.c kal_led_device.c kal_oled_device.c
  group cal
    ../SmartDevice/CAL/: cal_gpio_key.c cal_time.c cal_led_device.c cal_oled_device.c
  group input
    ../SmartDevice/Input_System/: gpio_key.c input_buffer.c input_system.c
  group unittest
    ../SmartDevice/Unit_Test/: input_test.c led_test.c diaplay_test.c
  group device
    ../SmartDevice/Device/: led_device.c
  group config
    ../SmartDevice/Config/: config.h
  group display
    ../SmartDevice/Device/diaplay/: display_device.c display_system.c oled_device.c
software components: CMSIS:CORE 4.3.0
